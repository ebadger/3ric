# Repository ebadger/3ric (continued)

## KiCad design kicad/3ric/3ric.kicad_pcb (continued)

Schematic: address_decoder.kicad_sch

Parts:
A1, A3, A5: 74LS08; DIP-14_W7.62mm_Socket
A2, A4: 74LS32; DIP-14_W7.62mm_Socket
B1, B5: 74LS08; DIP-14_W7.62mm_Socket
B2, B7: 74LS00; DIP-14_W7.62mm_Socket
B3, B4: 74LS32; DIP-14_W7.62mm_Socket
B6: 74LS04; DIP-14_W7.62mm_Socket
C2: 74LS04; DIP-14_W7.62mm_Socket
C5: 74LS08; DIP-14_W7.62mm_Socket

Connections:
!CA12: B5.12, B6.4
!CA12&!CA13: B3.5, B5.1, B5.11; also elsewhere on the board
!CA13: B5.13, B6.6
!PHI2: C2.10; also elsewhere on the board
!R~W: A1.4, A3.2, C2.12
!VIDENABLE: A2.10, A2.13, A4.13, A5.4; also elsewhere on the board
A13|A12: B1.13, B3.9, B4.8
A16: A3.11; also elsewhere on the board
B2: A1.13; also elsewhere on the board
BB: B1.10; also elsewhere on the board
C6XX: A5.2; also elsewhere on the board
CA8: B4.1; also elsewhere on the board
CA9: B4.2; also elsewhere on the board
CA10: B4.4; also elsewhere on the board
CA10|CA11: B4.6, B4.12
CA11: B3.10, B4.5; also elsewhere on the board
CA12: B4.9, B5.2, B6.3; also elsewhere on the board
CA13: B4.10, B6.5; also elsewhere on the board
CA14: B5.10, B7.4, C2.9; also elsewhere on the board
CA14&CA15: B5.8, B7.13; also elsewhere on the board
CA15: B1.12, B5.9, B7.5; also elsewhere on the board
DISKSS: C5.13; also elsewhere on the board
DXXX: B6.9, B7.11
unnamed: A1.3, A2.1
unnamed: A1.6, A2.2
unnamed: A1.8, A3.13
unnamed: A1.9, B6.8
unnamed: A1.10, A1.11
unnamed: A1.12, A2.3, A2.4
unnamed: A2.5, B3.6
unnamed: A2.6, B1.2
unnamed: A5.1, A5.6
unnamed: B1.1, B2.3
unnamed: B1.8, B2.1
unnamed: B1.9, B1.11
unnamed: B2.2, C2.8
unnamed: B3.1, B3.11
unnamed: B3.2, C2.2
unnamed: B3.4, B3.12, B7.6
unnamed: B3.8, B3.13
unnamed: B4.3, B4.13
unnamed: B5.3, B7.12
PHI2: A3.12, C2.11; also elsewhere on the board
RAMREAD: A1.2; also elsewhere on the board
RAMWRITE: A1.5; also elsewhere on the board
R~W: A1.1, A4.1, C2.13; also elsewhere on the board
SS: C2.1; also elsewhere on the board
SS_WRITE_SIGNAL: A4.2; also elsewhere on the board
VIDBUS: A5.12; also elsewhere on the board
VIDENABLE: A3.1; also elsewhere on the board
X0XX: B4.11; also elsewhere on the board
~CS_CPUBUS: A4.11; also elsewhere on the board
~CS_DEVICE: A2.8; also elsewhere on the board
~CS_RAM: A5.11; also elsewhere on the board
~CS_ROM2: A5.3; also elsewhere on the board
~CS_ROM: A2.11, A5.5
~DEVICE2: A2.9, B2.5, C5.11
~DEVICE: B3.3, C5.12
~OE: A3.3; also elsewhere on the board
~RAM: A4.12, A5.13, B2.6
~ROM: A2.12, B1.3, B2.4
~WE: A4.3; also elsewhere on the board

Schematic: banking.kicad_sch

Parts:
E1: 74LS32; DIP-14_W7.62mm_Socket
E2: 74LS08; DIP-14_W7.62mm_Socket
F1, F6: 74LS00; DIP-14_W7.62mm_Socket
F2: 74LS32; DIP-14_W7.62mm_Socket
F3, F4: 74LS112; DIP-16_W7.62mm_Socket
F5: 74LS14; DIP-14_W7.62mm_Socket
F7: 74LS08; DIP-14_W7.62mm_Socket
J_BEEP1: Conn_01x02_Pin; PinHeader_2x01_P2.54mm_Vertical
LED_BANK1: LED; LED_D5.0mm
LED_FF1: LED; LED_D5.0mm
LED_RO1: LED; LED_D5.0mm
LED_RRAM1: LED; LED_D5.0mm
LED_RROM1: LED; LED_D5.0mm
LED_RW1: LED; LED_D5.0mm
R13, R14, R15, R16, R17, R18: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
B1: F6.3, F6.4, LED_BANK1.2 (A); also elsewhere on the board
B2: F6.2, F6.6; also elsewhere on the board
BEEP: F4.9 (Q), J_BEEP1.1; also elsewhere on the board
BSS: E1.1, E1.4, E1.10, E1.13, F5.11; also elsewhere on the board
C030: F4.13 (C); also elsewhere on the board
CA3: F5.9, F6.12; also elsewhere on the board
FF: F3.3 (J), F4.5 (Q), LED_FF1.2 (A)
GND: F4.2 (K), J_BEEP1.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2; also elsewhere on the board
NOWRITE: F3.2 (K), F3.6 (~Q), LED_RO1.2 (A)
unnamed: E1.2, E2.3
unnamed: E1.3, F1.1, F1.12
unnamed: E1.5, E2.6
unnamed: E1.6, F1.2, F1.5
unnamed: E1.8, F1.4, F1.9
unnamed: E1.9, E2.8
unnamed: E1.11, F1.10, F1.13
unnamed: E1.12, E2.11
unnamed: F1.11, F5.13
unnamed: F2.8, F5.1
unnamed: F3.1 (C), F5.2
unnamed: F3.15 (~R), F4.15 (~R), F5.12
unnamed: F1.8, F2.10, F3.11 (J)
unnamed: F1.3, F2.9, F3.12 (K)
unnamed: F1.6, F4.3 (J)
unnamed: F5.8, F6.9
unnamed: F5.10, F7.13
unnamed: F6.1, F6.11
unnamed: F6.5, F6.8
unnamed: F6.10, F6.13, F7.11
unnamed: LED_BANK1.1 (K), R18.1
unnamed: LED_FF1.1 (K), R17.1
unnamed: LED_RO1.1 (K), R14.1
unnamed: LED_RRAM1.1 (K), R16.1
unnamed: LED_RROM1.1 (K), R15.1
unnamed: LED_RW1.1 (K), R13.1
PHI2: F3.13 (C), F4.1 (C), F7.12; also elsewhere on the board
RAMREAD: F3.7 (~Q), LED_RRAM1.2 (A); also elsewhere on the board
RAMWRITE: F3.5 (Q), LED_RW1.2 (A); also elsewhere on the board
ROMREAD: F3.9 (Q), LED_RROM1.2 (A)
VCC: F3.4 (~S), F3.14 (~R), F4.4 (~S), F4.10 (~S), F4.11 (J), F4.12 (K), F4.14 (~R); also elsewhere on the board
XXX0: E2.2; also elsewhere on the board
XXX1: E2.10; also elsewhere on the board
XXX2: E2.13; also elsewhere on the board
XXX3: E2.5; also elsewhere on the board
XXX8: E2.1; also elsewhere on the board
XXX9: E2.9; also elsewhere on the board
XXXA: E2.12; also elsewhere on the board
XXXB: E2.4; also elsewhere on the board
~RESET: F3.10 (~S); also elsewhere on the board

Schematic: Mockingboard.kicad_sch

Parts:
C48, C49, C50, C51: 106; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D7, D8, D9, D10, D11, D12: D; D_SMA-SMB_Universal_Handsoldering
J1, J4: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J3: STX-4235-3_3-N; STX423533N; Mouser Part Number 806-STX-4235-3/3-N
R37, R38: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
S1, S2: AY-3-8910; DIP-40_W15.24mm_Socket
T1_VIA1, T2_VIA1: 65C22S; DIP-40_W15.24mm_Socket

Connections:
BEEP: J3.A1, J3.A2; also elsewhere on the board
CA0: T1_VIA1.38 (RS0), T2_VIA1.38 (RS0); also elsewhere on the board
CA1: T1_VIA1.37 (RS1), T2_VIA1.37 (RS1); also elsewhere on the board
CA2: T1_VIA1.36 (RS2), T2_VIA1.36 (RS2); also elsewhere on the board
CA3: T1_VIA1.35 (RS3), T2_VIA1.35 (RS3); also elsewhere on the board
CA7: T2_VIA1.24 (CS1); also elsewhere on the board
CD0: T1_VIA1.33 (D0), T2_VIA1.33 (D0); also elsewhere on the board
CD1: T1_VIA1.32 (D1), T2_VIA1.32 (D1); also elsewhere on the board
CD2: T1_VIA1.31 (D2), T2_VIA1.31 (D2); also elsewhere on the board
CD3: T1_VIA1.30 (D3), T2_VIA1.30 (D3); also elsewhere on the board
CD4: T1_VIA1.29 (D4), T2_VIA1.29 (D4); also elsewhere on the board
CD5: T1_VIA1.28 (D5), T2_VIA1.28 (D5); also elsewhere on the board
CD6: T1_VIA1.27 (D6), T2_VIA1.27 (D6); also elsewhere on the board
CD7: T1_VIA1.26 (D7), T2_VIA1.26 (D7); also elsewhere on the board
FS0: S1.13 (IOB0); also elsewhere on the board
FS1: S1.12 (IOB1); also elsewhere on the board
FS2: S1.11 (IOB2); also elsewhere on the board
FS3: S1.10 (IOB3); also elsewhere on the board
FS4: S1.9 (IOB4); also elsewhere on the board
FS5: S1.8 (IOB5); also elsewhere on the board
GND: J3.A5, J3.B5, R37.1, R38.1, S1.1 (GND), S1.24 (~A9), S2.1 (GND), S2.24 (~A9), T1_VIA1.1 (VSS), T2_VIA1.1 (VSS); also elsewhere on the board
unnamed: C48.2, C49.1
unnamed: C49.2, J3.B1
unnamed: C50.2, C51.1
unnamed: C51.2, J3.B2
unnamed: D7.2 (A), S1.4 (OUTA)
unnamed: C48.1, D7.1 (K), D8.1 (K), D9.1 (K), R37.2
unnamed: D8.2 (A), S1.3 (OUTB)
unnamed: D9.2 (A), S1.38 (OUTC)
unnamed: D10.2 (A), S2.4 (OUTA)
unnamed: C50.1, D10.1 (K), D11.1 (K), D12.1 (K), R38.2
unnamed: D11.2 (A), S2.3 (OUTB)
unnamed: D12.2 (A), S2.38 (OUTC)
unnamed: J1.1, S2.6 (IOB7)
unnamed: J1.2, S2.7 (IOB6)
unnamed: J1.3, S2.8 (IOB5)
unnamed: J1.4, S2.9 (IOB4)
unnamed: J1.5, S2.10 (IOB3)
unnamed: J1.6, S2.11 (IOB2)
unnamed: J1.7, S2.12 (IOB1)
unnamed: J1.8, S2.13 (IOB0)
unnamed: J4.1, S2.14 (IOA7)
unnamed: J4.2, S2.15 (IOA6)
unnamed: J4.3, S2.16 (IOA5)
unnamed: J4.4, S2.17 (IOA4)
unnamed: J4.5, S2.18 (IOA3)
unnamed: J4.6, S2.19 (IOA2)
unnamed: J4.7, S2.20 (IOA1)
unnamed: J4.8, S2.21 (IOA0)
unnamed: S1.29 (BC1), T1_VIA1.10 (PB0)
unnamed: S1.27 (BDIR), T1_VIA1.11 (PB1)
unnamed: S1.37 (DA0), T1_VIA1.2 (PA0)
unnamed: S1.36 (DA1), T1_VIA1.3 (PA1)
unnamed: S1.35 (DA2), T1_VIA1.4 (PA2)
unnamed: S1.34 (DA3), T1_VIA1.5 (PA3)
unnamed: S1.33 (DA4), T1_VIA1.6 (PA4)
unnamed: S1.32 (DA5), T1_VIA1.7 (PA5)
unnamed: S1.31 (DA6), T1_VIA1.8 (PA6)
unnamed: S1.30 (DA7), T1_VIA1.9 (PA7)
unnamed: S1.23 (~RESET), T1_VIA1.12 (PB2)
unnamed: S2.29 (BC1), T2_VIA1.10 (PB0)
unnamed: S2.27 (BDIR), T2_VIA1.11 (PB1)
unnamed: S2.37 (DA0), T2_VIA1.2 (PA0)
unnamed: S2.36 (DA1), T2_VIA1.3 (PA1)
unnamed: S2.35 (DA2), T2_VIA1.4 (PA2)
unnamed: S2.34 (DA3), T2_VIA1.5 (PA3)
unnamed: S2.33 (DA4), T2_VIA1.6 (PA4)
unnamed: S2.32 (DA5), T2_VIA1.7 (PA5)
unnamed: S2.31 (DA6), T2_VIA1.8 (PA6)
unnamed: S2.30 (DA7), T2_VIA1.9 (PA7)
unnamed: S2.23 (~RESET), T2_VIA1.12 (PB2)
PHI2: S1.22 (CLOCK), S2.22 (CLOCK), T1_VIA1.25 (PHI2), T2_VIA1.25 (PHI2); also elsewhere on the board
R~W: T1_VIA1.22 (R~W), T2_VIA1.22 (R~W); also elsewhere on the board
VCC: S1.25 (A8), S1.28 (BC2), S1.40 (VCC), S2.25 (A8), S2.28 (BC2), S2.40 (VCC), T1_VIA1.20 (VDD), T2_VIA1.20 (VDD); also elsewhere on the board
~CA7: T1_VIA1.24 (CS1); also elsewhere on the board
~CS_MB: T1_VIA1.23 (~CS2), T2_VIA1.23 (~CS2); also elsewhere on the board
~IRQ_MB1: T1_VIA1.21 (~IRQ); also elsewhere on the board
~IRQ_MB2: T2_VIA1.21 (~IRQ); also elsewhere on the board
~RESET: T1_VIA1.34 (~RES), T2_VIA1.34 (~RES); also elsewhere on the board

Schematic: softswitches.kicad_sch

Parts:
C1: 74LS32; DIP-14_W7.62mm_Socket
D1, D2, D3: 74LS32; DIP-14_W7.62mm_Socket
D4: 74LS00; DIP-14_W7.62mm_Socket
D5, D6: 74LS154; DIP-24_W15.24mm_Socket
E3, E6: 74LS00; DIP-14_W7.62mm_Socket
E4, E5: 74LS32; DIP-14_W7.62mm_Socket
LED_BASIC1: LED; LED_D5.0mm
LED_FULL1: LED; LED_D5.0mm
LED_GFX1: LED; LED_D5.0mm
LED_HGR1: LED; LED_D5.0mm
LED_LGR1: LED; LED_D5.0mm
LED_MIX1: LED; LED_D5.0mm
LED_PG1, LED_PG2: LED; LED_D5.0mm
LED_TEXT1: LED; LED_D5.0mm
R7, R8, R9, R10, R11, R12, R19, R20, R21: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
!CA12&!CA13: D4.10; also elsewhere on the board
!PHI2: C1.9, D5.19 (E1), D6.19 (E1); also elsewhere on the board
BB: D4.2, D4.6, LED_BASIC1.2 (A); also elsewhere on the board
BSS: D1.11; also elsewhere on the board
C010: D1.3; also elsewhere on the board
C030: D1.8; also elsewhere on the board
C070: D1.6; also elsewhere on the board
CA0: D5.23 (A0); also elsewhere on the board
CA1: D5.22 (A1); also elsewhere on the board
CA2: D5.21 (A2); also elsewhere on the board
CA3: D5.20 (A3); also elsewhere on the board
CA4: D6.23 (A0); also elsewhere on the board
CA5: D6.22 (A1); also elsewhere on the board
CA6: D6.21 (A2); also elsewhere on the board
CA7: D6.20 (A3); also elsewhere on the board
CA14&CA15: D4.9; also elsewhere on the board
DISKSS: C1.3; also elsewhere on the board
FULLMODE: E3.1, E3.6, LED_FULL1.2 (A); also elsewhere on the board
GFXMODE: E6.1, E6.6, LED_GFX1.2 (A); also elsewhere on the board
GFXSS: D3.3, E4.1, E4.4, E4.10, E4.13, E5.1, E5.4, E5.10, E5.13
GND: D5.12 (GND), D5.18 (E0), D6.12 (GND), D6.18 (E0), R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R19.2, R20.2, R21.2; also elsewhere on the board
HIRES: E6.8, E6.13, LED_HGR1.2 (A); also elsewhere on the board
LORES: E6.10, E6.11, LED_LGR1.2 (A)
LOW0: D3.6
MIXEDMODE: E3.3, E3.4, LED_MIX1.2 (A)
unnamed: C1.10, D4.8
unnamed: C1.8, C1.12
unnamed: D1.1, D1.4, D1.10, D2.11
unnamed: D2.6, D4.1
unnamed: D2.8, D4.5
unnamed: D2.3, D2.4, D2.10
unnamed: D4.3, D4.4
unnamed: E3.2, E4.3
unnamed: E3.5, E4.6
unnamed: E3.9, E4.8
unnamed: E3.13, E4.11
unnamed: E5.3, E6.2
unnamed: E5.6, E6.5
unnamed: E5.8, E6.9
unnamed: E5.11, E6.12
unnamed: LED_BASIC1.1 (K), R21.1
unnamed: LED_FULL1.1 (K), R9.1
unnamed: LED_GFX1.1 (K), R7.1
unnamed: LED_HGR1.1 (K), R20.1
unnamed: LED_LGR1.1 (K), R19.1
unnamed: LED_MIX1.1 (K), R10.1
unnamed: LED_PG1.1 (K), R11.1
unnamed: LED_PG2.1 (K), R12.1
unnamed: LED_TEXT1.1 (K), R8.1
PAGE1: E3.8, E3.12, LED_PG1.2 (A); also elsewhere on the board
PAGE2: E3.10, E3.11, LED_PG2.2 (A)
SS: C1.2, C1.11, D1.13, D2.1, D2.13, D3.1; also elsewhere on the board
TEXTMODE: E6.3, E6.4, LED_TEXT1.2 (A)
VCC: D5.24 (VCC), D6.24 (VCC); also elsewhere on the board
X0XX: C1.13; also elsewhere on the board
XX0X: D2.2, D3.4, D6.1 (S0)
XX1X: D1.2, D6.2 (S1)
XX3X: D1.9, D6.4 (S3)
XX5X: D3.2, D6.6 (S5)
XX7X: D1.5, D6.8 (S7)
XX8X: D1.12, D6.9 (S8)
XXEX: C1.1, D6.16 (S14)
XXX0: D2.12, D3.5, D5.1 (S0), E5.2; also elsewhere on the board
XXX1: D5.2 (S1), E5.5; also elsewhere on the board
XXX2: D5.3 (S2), E4.2; also elsewhere on the board
XXX3: D5.4 (S3), E4.5; also elsewhere on the board
XXX4: D5.5 (S4), E4.12
XXX5: D5.6 (S5), E4.9
XXX6: D2.9, D5.7 (S6), E5.9
XXX7: D2.5, D5.8 (S7), E5.12
XXX8: D5.9 (S8); also elsewhere on the board
XXX9: D5.10 (S9); also elsewhere on the board
XXXA: D5.11 (S10); also elsewhere on the board
XXXB: D5.13 (S11); also elsewhere on the board

Schematic: PLL.kicad_sch

Parts:
C3: C30; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: C106; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
Q1: 74LS161; DIP-16_W7.62mm_Socket
Q2: 74LS20; DIP-14_W7.62mm_Socket
Q3: 4046; DIP-16_W7.62mm_Socket
R34: 30; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R35: R680K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R36: 51; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder

Connections:
GND: C4.2, Q1.8 (GND), Q2.7 (GND), Q2.9, Q2.10, Q2.12, Q2.13, Q3.5 (Inh), Q3.8 (VSS), R34.2, R35.2; also elsewhere on the board
unnamed: C4.1, R36.2
unnamed: Q1.14 (Q0), Q2.1
unnamed: Q1.13 (Q1), Q2.2, Q3.3 (RefIn)
unnamed: Q1.12 (Q2), Q2.4, Q2.5
unnamed: Q1.1 (~MR), Q2.6
unnamed: C3.1, Q3.6 (C1)
unnamed: C3.2, Q3.7 (C2)
unnamed: Q3.9 (VCOin), Q3.13 (PC2), R36.1
unnamed: Q3.11 (R1), R34.1
unnamed: Q3.10 (SFout), R35.1
PHI2: Q3.14 (SigIn); also elsewhere on the board
PHI7: Q1.2 (CP), Q3.4 (FOUT); also elsewhere on the board
VCC: Q1.7 (CEP), Q1.9 (~PE), Q1.10 (CET), Q1.16 (VCC), Q2.14 (VCC), Q3.16 (VDD); also elsewhere on the board

Board: 2 copper layers, 291 parts (154 on the bottom side), 468 nets, no tracks yet.
